<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\G030F6P6_LEDS_AND_KEYS.ewp</path>
  </project>
  <batchBuild />
</workspace>
